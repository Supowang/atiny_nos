# Keil uVision project sherlock.uvprojx, settings and files
target sherlock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sherlock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,AGENT_TINY_NOS,WITH_AT_FRAMEWORK,USE_ESP8266
  c include: ..\..\..\..\agent_tiny\comm\include;..\..\..\..\agent_tiny\examples;..\..\..\..\agent_tiny\lwm2m_client;..\..\..\..\agent_tiny\osadapter;..\..\..\..\core\inc;..\..\..\..\lwm2m\core;..\..\..\..\lwm2m\core\er-coap-13;..\..\..\..\network\inc;..\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_DSP_StdPeriph_Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lib
    ../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32F4xx_DSP_StdPeriph_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_gpio.c
  group core
    ../../../../core/libs/: mem_manager.c queue.c timer.c
    ../../../../core/hal_drv/: hal_init.c hal_mailbox.c hal_timer.c hal_uart.c
  group lwm2m
    ../../../../lwm2m/core/er-coap-13/: er-coap-13.c
    ../../../../lwm2m/core/: block1.c bootstrap.c data.c discover.c internals.h json.c liblwm2m.c liblwm2m.h list.c management.c objects.c observe.c packet.c registration.c tlv.c uri.c transaction.c utils.c
  group agenttiny
    ../../../../agent_tiny/examples/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../../../../agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c atiny_rpt.c commandline.c connection.c object_access_control.c object_binary_app_data_container.c object_device.c object_security.c object_server.c platform_adapter.c
    ../../../../agent_tiny/osadapter/: atiny_adapter.c atiny_socket.c
  group Src
    ../../src/: main.c
  group drivers
    ../../driver/: drv_delay.c drv_timer.c drv_uart.c drv_debug_uart.c
  group network
    ../../../../network/: at_api_interface.c esp8266.c sim900a.c
