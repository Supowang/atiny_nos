# Keil uVision project nrf51822-sherlock.uvprojx, settings and files
target sherlock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822-sherlock +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o sherlock.bin ./Objects/nrf51822-sherlock.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,AGENT_TINY_NOS
  c include: ..\agent_tiny\comm\include;..\agent_tiny\examples;..\agent_tiny\lwm2m_client;..\agent_tiny\osadapter;..\components\toolchain;..\components\toolchain\arm;..\components\libraries\mailbox;..\components\libraries\mem_manager;..\components\libraries\scheduler;..\components\libraries\timer;..\components\libraries\uart;..\components\libraries\util;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\delay;..\components\drivers_nrf\uart;..\hw_init;..\lwm2m\core;..\lwm2m\core\er-coap-13;..\components\toolchain\gcc;..\components\drivers_nrf\hal;..\components\softdevice\s110\headers;..\components\libraries\trace;..\hw_init\network
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../Src/: main.c
  group lib
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/libraries/uart/: app_uart.c
    ../components/libraries/mem_manager/: mem_manager.c
    ../components/libraries/mailbox/: app_mailbox.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/util/: app_error.c app_util_platform.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
  group device
    ../components/toolchain/arm/: arm_startup_nrf51.s
    ../components/toolchain/: system_nrf51.c
  group hardware
    ../hw_init/: sys_init.c hw_uart.c hw_timer.c hw_mailbox.c
  group agenttiny
    ../agent_tiny/examples/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c atiny_rpt.c commandline.c connection.c object_access_control.c object_binary_app_data_container.c object_device.c object_security.c object_server.c platform_adapter.c
  group atiny_adapter
    ../agent_tiny/osadapter/: atiny_adapter.c atiny_socket.c
  group lwm2m
    ../lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
    ../lwm2m/core/er-coap-13/: er-coap-13.c
  group network
    ../hw_init/network/: esp8266.c u2n_if.c
